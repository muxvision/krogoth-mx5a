RDEPENDS_${PN}_remove = " \
	ltp \
"   

