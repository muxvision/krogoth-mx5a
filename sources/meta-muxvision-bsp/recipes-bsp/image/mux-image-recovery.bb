CRIPTION = "Muxvision Image - Recovery"
LICENSE = "MIT"


require recipes-core/images/core-image-minimal.bb 

IMAGE_INSTALL += " \
"
